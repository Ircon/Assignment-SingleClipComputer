# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c KS0108.h lang.h DS1302.h DS18B20.h
    C:/Keil_v5/C51/LIB/: C51S.LIB
