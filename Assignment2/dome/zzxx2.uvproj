# Keil uVision project zzxx2.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: zzxx2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Hzimo.h KS0108.h zzxx2.c DS1302.h DS18B20.h keyscan.h
